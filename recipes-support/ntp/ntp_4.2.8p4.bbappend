FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

EXTRA_OECONF += "--libexecdir=/usr/lib/ntp \
		"