 
inherit elphel-scp
 