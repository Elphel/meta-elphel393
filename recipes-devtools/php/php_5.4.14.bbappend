PACKAGECONFIG := "sqlite3"